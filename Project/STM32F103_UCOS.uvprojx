# Keil uVision project STM32F103_UCOS.uvprojx, settings and files
target STM32F103_UCOS (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103_UCOS +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\STM32\CMSIS;..\STM32\LIB\inc;..\UCOS\MDK\uC-CPU;..\UCOS\MDK\uC-LIB;..\UCOS\MDK\uCOS-III\Ports;..\UCOS\MDK\uCOS-III\Source;..\USER;..\USER\BSP;..\USER\APP
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STM32_CMSIS
    ../STM32/CMSIS/: core_cm3.c stm32f10x_it.c system_stm32f10x.c
  group STM32_LIB
    ../STM32/LIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group STM32_START
    ../STM32/STARTUP/MDK/: startup_stm32f10x_hd.s
  group UCOS_LIB
    ../UCOS/MDK/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c lib_mem_a.asm
  group UCOS_CPU
    ../UCOS/MDK/uC-CPU/: cpu_a.asm cpu_c.c cpu_core.c
  group UCOS_III
    ../UCOS/MDK/uCOS-III/Ports/: os_cpu_a.s os_cpu_c.c
    ../UCOS/MDK/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group USER
    ../USER/BSP/: bsp.c
    ../USER/APP/: app.c os_app_hooks.c
